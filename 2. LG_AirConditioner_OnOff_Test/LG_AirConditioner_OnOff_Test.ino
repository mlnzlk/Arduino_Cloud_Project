/*
 * An IR LED must be connected to Arduino PWM pin 3.
*/


#include <IRremote.h>

IRsend irsend;

void setup()
{
  Serial.begin(9600);
}

void loop()
{
  if(Serial.available())
  {
    char input_char = (char)Serial.read();
  
    if(input_char == '0')
    {
      for (int i = 0; i < 3; i++)
      {
        irsend.sendLG(0x88C0051, 28);   //OFF
        delay(40);
      } 
    }
    else if(input_char == '1')
    {
      for (int i = 0; i < 3; i++)
      {
        irsend.sendLG(0x8800909, 28);  //ON
        delay(40);
      } 
    }
    else
    {
      Serial.println("You sent invalid command! Just only '0' or '1'");
    }
  }
}